Commit message: Fixing gazebo and origin tags

File: src/Camera_description/src/model.urdf (robot description, URDF)
Before this commit: robot Camera Sensor, 1 links, 0 joints
Links:
- link outerframe: geometry collision box size=0.1 0.04 0.05; collision cylinder length=0.02 radius=0.02
